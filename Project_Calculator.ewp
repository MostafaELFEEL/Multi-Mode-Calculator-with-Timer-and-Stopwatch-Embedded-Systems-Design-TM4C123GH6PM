# IAR project Project_Calculator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Calculator.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bitwise_operation.h delay.c delay.h DIO.c DIO.h gptimer0.c gptimer0.h keypad.c keypad.h main.c modes.c modes.h startup_ewarm.c systick.c systick.h tm4c.h UART.c UART.h
